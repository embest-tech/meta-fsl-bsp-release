# Copyright (C) 2012-2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

PR = "${INC_PR}.0"
PE = "2"

SRC_URI[md5sum] = "8829467d9511cc99c79ecd79ce43f34d"
SRC_URI[sha256sum] = "845fd1567fc241caaaed041c6254cc66329fe8742312c021505d95af81bb4f2a"

COMPATIBLE_MACHINE = "(mx6)"
