# Copyright (C) 2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

PR = "${INC_PR}.0"
PE = "2"

SRC_URI[md5sum] = "bfdae0e2c6f7355c370c9bb6cd3ab9f9"
SRC_URI[sha256sum] = "657a1a67e26889efcecd8272a4420d88c0fc2a103d6551d0f126d8fe8c333a39"
#SRC_URI[md5sum] = "ca71dddf6fe6877a6c7fbe99bbb41099"
#SRC_URI[sha256sum] = "e9a060254b1a0a5d24c6601210095edaa702ea9c7ec9329aca1d3842de04bee2"


COMPATIBLE_MACHINE = "(mx6)"
